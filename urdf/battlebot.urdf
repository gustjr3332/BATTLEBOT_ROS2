Commit message: Added new feature

File: urdf/battlebot.urdf (robot description, URDF)
Before this commit: robot battlebot, 5 links, 4 joints
Links:
- link saw_link: geometry collision cylinder length=0.01 radius=0.3; visual cylinder length=0.01 radius=0.3
